FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://nobootdelay.cfg"
