FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://printk_time.cfg \
            file://realtek.cfg"
